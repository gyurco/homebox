RRECOMMENDS_${PN} += 'kernel-module-snd-usb-audio'
RRECOMMENDS_${PN} += 'kernel-module-snd-hda-codec'
RRECOMMENDS_${PN} += 'kernel-module-snd-hda-codec-analog'
RRECOMMENDS_${PN} += 'kernel-module-snd-hda-codec-ca0110'
RRECOMMENDS_${PN} += 'kernel-module-snd-hda-codec-ca0132'
RRECOMMENDS_${PN} += 'kernel-module-snd-hda-codec-cirrus'
RRECOMMENDS_${PN} += 'kernel-module-snd-hda-codec-cmedia'
RRECOMMENDS_${PN} += 'kernel-module-snd-hda-codec-conexant'
RRECOMMENDS_${PN} += 'kernel-module-snd-hda-codec-generic'
RRECOMMENDS_${PN} += 'kernel-module-snd-hda-codec-hdmi'
RRECOMMENDS_${PN} += 'kernel-module-snd-hda-codec-idt'
RRECOMMENDS_${PN} += 'kernel-module-snd-hda-codec-realtek'
RRECOMMENDS_${PN} += 'kernel-module-snd-hda-codec-si3054'
RRECOMMENDS_${PN} += 'kernel-module-snd-hda-controller'
RRECOMMENDS_${PN} += 'kernel-module-snd-hda-intel'
