RRECOMMENDS_${PN} += 'kernel-module-btusb'
