RRECOMMENDS_${PN} += 'kernel-module-kvm'
RRECOMMENDS_${PN} += 'kernel-module-kvm-intel'
RRECOMMENDS_${PN} += 'kernel-module-kvm-amd'
