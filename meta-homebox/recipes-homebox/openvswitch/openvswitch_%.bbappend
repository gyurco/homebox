RRECOMMENDS_${PN} += 'kernel-module-openvswitch'
